Commit message: feat(sim) : add simplified scoop design and urdf

File: ur_urdf/ur5_with_scoop_v2.urdf (robot description, URDF)
Before this commit: robot ur5_with_scoop, 13 links, 12 joints
Links:
- link scoop_link: geometry collision mesh filename=newscoop.stl scale=0.001 0.001 0.001
